# Repository AirchipTeknoloji/0011_Distance_Module_TMF8828

## KiCad design 0011_Distance_Module_TMF8828.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
IC1: TMF8820-1AM; TMF88201AM; Manufacturer_Part_Number TMF8820-1AM
R1, R2, R5, R6: 10k; R_0603_1608Metric
R3, R4: 4.7k; R_0603_1608Metric
R7: 470r; R_0603_1608Metric
U1: air_module

Connections:
+3V3: C1.1, C2.1, C3.1, IC1.1 (VDDC), IC1.7 (VDD), IC1.12 (VDDV), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, U1.8 (3V3)
EN: IC1.9 (EN), R1.2, U1.12 (GPIO)
GND: C1.2, C2.2, C3.2, D1.1 (K), IC1.2 (GNDC), IC1.8 (GND), IC1.11 (GNDV), U1.9 (GND)
GPIO0: IC1.3 (GPIO0), R6.2, U1.14 (GPIO)
GPIO1: IC1.10 (GPIO1), R2.2, U1.15 (GPIO)
INT: IC1.4 (INT), R5.2, U1.13 (GPIO)
unnamed: D1.2 (A), R7.2
SCL: IC1.5 (SCL), R4.2, U1.5 (SCL)
SDA: IC1.6 (SDA), R3.2, U1.6 (SDA)

Notes on the sheet:
SENSOR
AIR PIN

Board: 2 copper layers, 40.0 x 30.0 mm, 13 parts (0 on the bottom side), 9 nets.
